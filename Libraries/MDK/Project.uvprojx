# Keil uVision project Project.uvprojx, settings and files
target RandleH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB USE_HAL_DRIVER
  c include: ..\Libraries\STM32F1xx_HAL_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\STM32F1xx_HAL_Driver\inc\Legacy;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c main.h
    ../User/src/: stm32f1xx_it.c
    ../User/inc/: stm32f1xx_hal_conf.h
  group HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/: system_stm32f1xx.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/startup/arm/: startup_stm32f103xb.s
